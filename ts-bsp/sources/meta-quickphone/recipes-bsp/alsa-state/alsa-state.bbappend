FILESEXTRAPATHS_prepend_tsimx6 := "${THISDIR}/${PN}/tsimx6:"

PACKAGE_ARCH_tsimx6 = "${MACHINE_ARCH}"
