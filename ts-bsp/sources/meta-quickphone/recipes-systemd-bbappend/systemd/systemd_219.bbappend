SRC_URI_remove = " \
    file://udev-re-enable-mount-propagation-for-udevd.patch \
"
