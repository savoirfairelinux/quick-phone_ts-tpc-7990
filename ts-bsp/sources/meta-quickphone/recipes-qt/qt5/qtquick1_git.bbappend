# Remove qtwebkit
PACKAGECONFIG_remove = "webkit"
