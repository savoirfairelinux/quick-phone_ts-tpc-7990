# Allow qt to use fontconfig to locate fonts
PACKAGECONFIG_append = " fontconfig"
